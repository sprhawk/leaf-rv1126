# Repository sprhawk/leaf-rv1126 (continued)

## KiCad design leaf.kicad_pcb (continued)

Schematic: Ethernet.kicad_sch, Leaf RV1126

Parts:
U2: rv1126/rv1109; Rockchip_RV1126_FCCSP409LD_14.0x14.0mm

Schematic: VCCIO4.kicad_sch, Leaf RV1126

Parts:
C24, C26, C28, C29, C30, C31: 100nF X5R 6.3V; C_0201_0603Metric; LCSC C76928
C25, C27: 10uF X5R 6.3V; C_0402_1005Metric; LCSC C77000
J2: MIPI-CSI; Hirose_FH12-24S-0.5SH_1x24-1MP_P0.50mm_Horizontal
R21, R22: 2.2K 5%; R_0402_1005Metric; LCSC C966701
R23, R24: 0R 5%; R_0402_1005Metric; LCSC C17168
U2: rv1126/rv1109; Rockchip_RV1126_FCCSP409LD_14.0x14.0mm

Connections:
/VCCIO4/MIPI_CSI_AVDD_0V8: C31.1, R24.2, U2.T15 (MIPI_CSI_RX0_AVDD_0V8)
/VCCIO4/MIPI_CSI_AVDD_1V8: C30.1, R23.2, U2.T16 (MIPI_CSI_RX0_AVDD_1V8)
/VCCIO4/MIPI_CSI_I2C_SCL: J2.6, R22.1, U2.Y21 (I2C1_SCL/UART4_CTSN_M2/GPIO1_D3_u)
/VCCIO4/MIPI_CSI_I2C_SDA: J2.5, R21.1, U2.W19 (I2C1_SDA/UART4_RTSN_M2/GPIO1_D2_u)
/VCCIO4/MIPI_CSI_MCLK0: J2.21, U2.V21 (MIPI_CSI_CLK0/UART5_CTSN_M2/GPIO2_A3_d)
/VCCIO4/MIPI_CSI_PWR0: J2.3, U2.W20 (UART4_RX_M2/GPIO1_D4_d)
/VCCIO4/MIPI_CSI_RST0: J2.4, U2.V19 (SPI0_MOSI_M1/I2S1_SCLK_M1/I2C3_SCL_M2/G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)
/VCCIO4/MIPI_RX0_CLKN: J2.18, U2.V15 (MIPI_CSI_RX0_CLKN/LVDS0_CLKN)
/VCCIO4/MIPI_RX0_CLKP: J2.19, U2.U15 (MIPI_CSI_RX0_CLKP/LVDS0_CLKP)
/VCCIO4/MIPI_RX0_D0N: J2.9, U2.U16 (MIPI_CSI_RX0_D0N/LVDS0_RX0N)
/VCCIO4/MIPI_RX0_D0P: J2.10, U2.V16 (MIPI_CSI_RX0_D0P/LVDS0_RX0P)
/VCCIO4/MIPI_RX0_D1N: J2.11, U2.W16 (MIPI_CSI_RX0_D1N/LVDS0_RX1N)
/VCCIO4/MIPI_RX0_D1P: J2.12, U2.Y16 (MIPI_CSI_RX0_D1P/LVDS0_RX1P)
/VCCIO4/MIPI_RX0_D2N: J2.13, U2.Y15 (MIPI_CSI_RX0_D2N/LVDS0_RX2N)
/VCCIO4/MIPI_RX0_D2P: J2.14, U2.W15 (MIPI_CSI_RX0_D2P/LVDS0_RX2P)
/VCCIO4/MIPI_RX0_D3N: J2.15, U2.AA16 (MIPI_CSI_RX0_D3N/LVDS0_RX3N)
/VCCIO4/MIPI_RX0_D3P: J2.16, U2.AA15 (MIPI_CSI_RX0_D3P/LVDS0_RX3P)
/VCCIO4/VCC1V8_DOVDD: C29.1, J2.22, R21.2, R22.2
/VCCIO4/VCCAVDD_RGB: C25.1, C26.1, J2.24
/VCCIO4/VCCDVDD_RGB: C27.1, C28.1, J2.23
GND: C24.2, C25.2, C26.2, C27.2, C28.2, C29.2, J2.MP (MountPin); also elsewhere on the board
GNDA: C30.2, C31.2; also elsewhere on the board
GNDD: J2.1, J2.2, J2.7, J2.8, J2.17, J2.20; also elsewhere on the board
VCC_0V8: R24.1; also elsewhere on the board
VCC_1V8: C24.1, R23.1, U2.P15 (VCCIO4_VDD); also elsewhere on the board

Schematic: USB.kicad_sch, Leaf RV1126

Parts:
C33, C35, C36, C37, C38: 100nF X5R 6.3V; C_0201_0603Metric; LCSC C76928
C34: 22uF X5R 10V; C_0603_1608Metric; LCSC C162690
D9, D10, D11, D12: ESD9B5.0ST5G; D_SOD-923
FL1: Filter_EMI_CommonMode; L_CommonModeChoke_Coilcraft_0603USB
J3: USB_OTG; USB_Micro-B_Amphenol_10118194_Horizontal
Q1: Q_PNP_BEC; SOT-23
R25, R26: 2.2R 5%; R_0603_1608Metric
R27: 100R 5%; R_0402_1005Metric; LCSC C25138
R28, R29: 200R 1%; R_0402_1005Metric
R30: 18K 1%; R_0402_1005Metric
R31: 10K 1%; R_0402_1005Metric
R32: 1K 5%; R_0402_1005Metric
R33: 2.2K 5%; R_0402_1005Metric; LCSC C966701
R34: 220R 5%; R_0402_1005Metric
U2: rv1126/rv1109; Rockchip_RV1126_FCCSP409LD_14.0x14.0mm

Connections:
/USB/OTG_DET_1V8: C35.1, R30.1, R31.2, U2.V5 (OTG_VBUS_1V8)
/USB/OTG_DM: FL1.3, R26.1, R34.2, U2.W4 (OTG_DM)
/USB/OTG_DP: FL1.1, R25.1, U2.W3 (OTG_DP)
/USB/OTG_ID: R27.1, U2.Y3 (OTG_ID)
/USB/OTG_PORT_DM: D12.1 (A1), FL1.4, J3.2 (D-), R26.2
/USB/OTG_PORT_DP: D11.1 (A1), FL1.2, J3.3 (D+), R25.2
/USB/USB_HOST_DM: U2.Y2 (HOST_DM)
/USB/USB_HOST_DP: U2.Y1 (HOST_DP)
/USB_CTRL: R33.2; also elsewhere on the board
GND: C33.1, C34.1, C35.2, C36.2, C37.2, C38.2, D9.2 (A2), D10.2 (A2), D11.2 (A2), D12.2 (A2), J3.5 (GND), J3.6 (Shield), R28.2, R29.2, R31.1; also elsewhere on the board
unnamed: D10.1 (A1), J3.4 (ID), R27.2
unnamed: Q1.1 (B), R32.2, R33.1
unnamed: Q1.3 (C), R34.1
unnamed: R29.1, U2.U5 (HOST_EXTR)
unnamed: R28.1, U2.U6 (OTG_EXTR)
VCC5V0_USB: C33.2, C34.2, D9.1 (A1), J3.1 (VBUS), R30.2
VCC_0V8: C38.1, U2.R6 (USB_AVDD_0V8); also elsewhere on the board
VCC_1V8: C37.1, U2.R7 (USB_AVDD_1V8); also elsewhere on the board
VCC_3V3: C36.1, Q1.2 (E), R32.1, U2.T7 (USB_AVDD_3V3); also elsewhere on the board

Notes on the sheet:
USB2.0 Design Rules 1. Max intra-pair skew < 4ps 2. Max trace length < 6 inches 3. Max allowed via < 6 4. Trace impedance 90ohm +/- 10% 5. The distance between other signals follows the 3W rule
摘自《瑞芯微 RV1126/RV1109 硬件设计指南》 1. USB_ID内部上拉到USB_AVDD_1V8, 所以OTG默认为Device 2. OTG_VBUS_1V8通过一个18K电阻和一个10K电阻分压VCC5V0_USB做输入检测， 检测电压为1.62V~2.08V，检测高电平说明有 USB 插入 3. USB 控制器参考电阻200 ohm请选用 1% 精度的电阻，该电阻关系到 USB 幅 度并影响眼图质量 4. 为提高 USB 性能，控制器电源的去耦电容要靠近管脚放置 5. 为抑制电磁辐射，可以都督在信号线上预留共模电感，在调测过程中根据实际情 况选择使用2.2R电阻或者共模电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
参考设计中需要将此电路靠近R2502

Schematic: WiFi.kicad_sch, Leaf RV1126

Parts:
AE1: Antenna_Chip; Johanson_2450AT18x100; not fitted
C32: 100nF; C_0201_0603Metric; not fitted
U4: AP6526; QFN-44_12x12_Pitch0.9mm; not fitted
Y1: Crystal; not fitted

Connections:
/WiFi/ANTENNA: AE1.1 (FEED), U4.2 (WL_BT_ANT)
/WiFi/SDIO_CLK: U4.17 (SDIO_CLK)
/WiFi/SDIO_CMD: U4.16 (SDIO_CMD)
/WiFi/SDIO_D0: U4.18 (SDIO_D0)
/WiFi/SDIO_D1: U4.19 (SDIO_D1)
/WiFi/SDIO_D2: U4.14 (SDIO_D2)
/WiFi/SDIO_D3: U4.15 (SDIO_D3)
/WiFi/SDIO_VSEL: U4.29 (SDIO_VSEL)
/WiFi/UART_RXD: U4.43 (UART_RXD)
/WiFi/UART_TXD: U4.42 (UART_TXD)
/WiFi/UART_~CTS: U4.44 (UART_~CTS)
/WiFi/UART_~RTS: U4.41 (UART_~RTS)
/WiFi/XTAL_IN: U4.10 (XTAL_IN), Y1.2
/WiFi/XTAL_OUT: U4.11 (XTAL_OUT), Y1.1
GND: C32.2, U4.1 (GND), U4.3 (GND), U4.20 (GND), U4.31 (GND), U4.33 (GND), U4.36 (GND); also elsewhere on the board
unnamed: AE1.2 (PCB_Trace), C32.1

Schematic: Power.kicad_sch, Leaf RV1126

Parts:
C1: 10uF X5R 10V; C_0402_1005Metric; LCSC C77000
C2, C3: 22uF X5R 10V; R_0603_1608Metric; LCSC C162690
C4: 100nF X5R 6.3V; C_0201_0603Metric; LCSC C76928
C5: 100nF X5R 10V; C_0402_1005Metric; LCSC C76934
C6: 22pF 50V C0G; C_0201_0603Metric; LCSC C76924
L1: 2.2uH 0.102 ohm 2.30A; L_0805_2012Metric; LCSC C2044190
NT1: NetTie_3_Tee; NetTie-3_SMD_Pad2.0mm
R1: 56K 1%; R_0402_1005Metric; LCSC C54968
R2: 100R 5%; R_0402_1005Metric; LCSC C25138
R3: 43.2K 1%; R_0402_1005Metric; LCSC C25894
R4: 115K 1%; R_0402_1005Metric; LCSC C25747
U1: BL8039; SOT-23-5_HandSoldering; LCSC C2924844

Connections:
GND: NT1.2; also elsewhere on the board
GNDA: C1.2, C2.2, C3.2, C4.1, C5.1, NT1.1, R4.2, U1.2 (GND); also elsewhere on the board
GNDD: NT1.3; also elsewhere on the board
unnamed: C5.2, R1.2, U1.1 (EN)
unnamed: C6.2, R3.1, R4.1, U1.5 (FB)
unnamed: L1.1, U1.3 (SW)
VCC5V0_SYS: C1.1, U1.4 (VIN); also elsewhere on the board
VCC_BUCK5: R1.1; also elsewhere on the board
VDD_LOGIC: C2.1, C3.1, C4.2, C6.1, L1.2, R2.1, R2.2, R3.2; also elsewhere on the board

Notes on the sheet:
Feedback from far-end
2A 0.8V

Schematic: DDR_Chips.kicad_sch, Leaf RV1126

Parts:
C126: 100pF C0G 50V; C_0402_1005Metric; LCSC C1546
R60, R61: 75R 1%; R_0402_1005Metric; LCSC C25133
R62, R63: 33R 1%; R_0402_1005Metric; LCSC C25105
R64, R65: 49.9R 1%; R_0402_1005Metric; LCSC C25120
RN1, RN2, RN3, RN4, RN5, RN6: 49.9R 1%; R_Array_Concave_4x0402; LCSC C136850

Connections:
/DDR/DDR4_A0: RN3.5 (R4.2); also elsewhere on the board
/DDR/DDR4_A1: RN4.5 (R4.2); also elsewhere on the board
/DDR/DDR4_A2: RN6.8 (R1.2); also elsewhere on the board
/DDR/DDR4_A3: RN5.7 (R2.2); also elsewhere on the board
/DDR/DDR4_A4: RN3.7 (R2.2); also elsewhere on the board
/DDR/DDR4_A5: RN5.8 (R1.2); also elsewhere on the board
/DDR/DDR4_A6: RN3.6 (R3.2); also elsewhere on the board
/DDR/DDR4_A7: RN4.6 (R3.2); also elsewhere on the board
/DDR/DDR4_A8: RN6.7 (R2.2); also elsewhere on the board
/DDR/DDR4_A9: RN4.7 (R2.2); also elsewhere on the board
/DDR/DDR4_A10: RN1.5 (R4.2); also elsewhere on the board
/DDR/DDR4_A11: RN6.6 (R3.2); also elsewhere on the board
/DDR/DDR4_A12: RN1.7 (R2.2); also elsewhere on the board
/DDR/DDR4_A13: RN4.8 (R1.2); also elsewhere on the board
/DDR/DDR4_A14_~WE: RN2.8 (R1.2); also elsewhere on the board
/DDR/DDR4_A15_~CAS: RN2.5 (R4.2); also elsewhere on the board
/DDR/DDR4_A16_~RAS: RN2.7 (R2.2); also elsewhere on the board
/DDR/DDR4_BA0: RN3.8 (R1.2); also elsewhere on the board
/DDR/DDR4_BA1: RN5.5 (R4.2); also elsewhere on the board
/DDR/DDR4_BG0: RN1.6 (R3.2); also elsewhere on the board
/DDR/DDR4_CKE: R65.1; also elsewhere on the board
/DDR/DDR4_CLK_N: R63.1; also elsewhere on the board
/DDR/DDR4_CLK_P: R62.1; also elsewhere on the board
/DDR/DDR4_ODT0: R64.1; also elsewhere on the board
/DDR/DDR4_~ACT: RN2.6 (R3.2); also elsewhere on the board
/DDR/DDR4_~CS0: RN1.8 (R1.2); also elsewhere on the board
/DDR/DDR Chips/DDR4_A0_B: RN3.4 (R4.1); also elsewhere on the board
/DDR/DDR Chips/DDR4_A1_B: RN4.4 (R4.1); also elsewhere on the board
/DDR/DDR Chips/DDR4_A2_B: RN6.1 (R1.1); also elsewhere on the board
/DDR/DDR Chips/DDR4_A3_B: RN5.2 (R2.1); also elsewhere on the board
/DDR/DDR Chips/DDR4_A4_B: RN3.2 (R2.1); also elsewhere on the board
/DDR/DDR Chips/DDR4_A5_B: RN5.1 (R1.1); also elsewhere on the board
/DDR/DDR Chips/DDR4_A6_B: RN3.3 (R3.1); also elsewhere on the board
/DDR/DDR Chips/DDR4_A7_B: RN4.3 (R3.1); also elsewhere on the board
/DDR/DDR Chips/DDR4_A8_B: RN6.2 (R2.1); also elsewhere on the board
/DDR/DDR Chips/DDR4_A9_B: RN4.2 (R2.1); also elsewhere on the board
/DDR/DDR Chips/DDR4_A10_B: RN1.4 (R4.1); also elsewhere on the board
/DDR/DDR Chips/DDR4_A11_B: RN6.3 (R3.1); also elsewhere on the board
/DDR/DDR Chips/DDR4_A12_B: RN1.2 (R2.1); also elsewhere on the board
/DDR/DDR Chips/DDR4_A13_B: RN4.1 (R1.1); also elsewhere on the board
/DDR/DDR Chips/DDR4_A14_~WE_B: RN2.1 (R1.1); also elsewhere on the board
/DDR/DDR Chips/DDR4_A15_~CAS_B: RN2.4 (R4.1); also elsewhere on the board
/DDR/DDR Chips/DDR4_A16_~RAS_B: RN2.2 (R2.1); also elsewhere on the board
/DDR/DDR Chips/DDR4_BA0_B: RN3.1 (R1.1); also elsewhere on the board
/DDR/DDR Chips/DDR4_BA1_B: RN5.4 (R4.1); also elsewhere on the board
/DDR/DDR Chips/DDR4_BG0_B: RN1.3 (R3.1); also elsewhere on the board
/DDR/DDR Chips/DDR4_CKE_B: R65.2; also elsewhere on the board
/DDR/DDR Chips/DDR4_CLK_B_N: R61.1, R63.2; also elsewhere on the board
/DDR/DDR Chips/DDR4_CLK_B_P: R60.1, R62.2; also elsewhere on the board
/DDR/DDR Chips/DDR4_ODT0_B: R64.2; also elsewhere on the board
/DDR/DDR Chips/DDR4_~ACT_B: RN2.3 (R3.1); also elsewhere on the board
/DDR/DDR Chips/DDR4_~CS0_B: RN1.1 (R1.1); also elsewhere on the board
GND: C126.2; also elsewhere on the board
unnamed: C126.1, R60.2, R61.2

Schematic: DDR_Power.kicad_sch, Leaf RV1126

Parts:
C108, C110: 100nF X5R 10V; C_0402_1005Metric; LCSC C76934
C109, C112: 1uF ±10% 6.3V; C_0402_1005Metric; LCSC C88945
C111: 2.2uF X5R 10V; C_0402_1005Metric
C113, C114, C115, C116: 1nF X5R 50V; C_0402_1005Metric; LCSC C77018
R55, R57: 1K 1%; R_0402_1005Metric; LCSC C11702
R56: 240R 1%; R_0402_1005Metric
U6: NCP114AMX250TCG; OnSemi_XDFN4-1EP_1.0x1.0mm_EP0.52x0.52mm

Connections:
/DDR/DDR_VREFCA: C113.1, C114.1, C115.1, C116.1, R55.2, R57.1; also elsewhere on the board
/DDR/VCC2V5_DDR: C108.2, C109.1, C110.2, C111.2, U6.1 (OUT); also elsewhere on the board
GND: C108.1, C109.2, C110.1, C111.1, C112.2, C113.2, C114.2, C115.2, C116.2, R57.2, U6.2 (GND), U6.5 (GND); also elsewhere on the board
unnamed: R56.2, U6.3 (EN)
VCC3V3_SYS: C112.1, R56.1, U6.4 (IN); also elsewhere on the board
VCC_DDR: R55.1; also elsewhere on the board

Notes on the sheet:
For Samsung KA4AG165WE, I_{pp} (total PINs) is 29mA max For GigaDevice GDQ2BFAA, I_{pp} (total PINs) is 22mA Max
DDR4: 1.2V
Close to DDR

Schematic: SoC_Power_GND.kicad_sch, Leaf RV1126

Parts:
C39, C43, C44, C45, C49, C50, C53, C54, C57, C58: 100nF X5R 6.3V; C_0201_0603Metric; LCSC C76928
C40, C46, C51, C55: 10uF X5R 10V; C_0402_1005Metric; LCSC C77000
C41, C42, C47, C48, C52, C56: 1uF X5R 6.3V; C_0402_1005Metric; LCSC C15684
C59, C60: 10uF X5R 10V; C_0402_1005Metric; LCSC C77000; not fitted
U2: rv1126/rv1109; Rockchip_RV1126_FCCSP409LD_14.0x14.0mm

Connections:
GND: C39.2, C40.2, C41.2, C42.2, C43.2, C44.2, C45.2, C46.2, C47.2, C48.2, C49.2, C50.2, C51.2, C52.2, C53.2, C54.2, C55.2, C56.2, C57.2, C58.2, C59.2, C60.2, U2.A1 (VSS_1), U2.A21 (AVSS_1), U2.AA1 (VSS_95), U2.AA10 (VSS_96), U2.AA21 (VSS_97), U2.B12 (VSS_2), U2.C3 (VSS_3), U2.C5 (VSS_4), U2.C7 (VSS_5), U2.C10 (VSS_6), U2.C12 (VSS_7), U2.D9 (VSS_8), U2.D12 (VSS_9), U2.D18 (AVSS_2), U2.E4 (VSS_10), U2.E6 (VSS_11), U2.E8 (VSS_12), U2.E9 (VSS_13), U2.E10 (VSS_14), U2.E11 (VSS_15), U2.E12 (VSS_16), U2.F3 (VSS_17), U2.F5 (VSS_18), U2.F7 (VSS_19), U2.F8 (VSS_20), U2.F9 (VSS_21), U2.F10 (VSS_22), U2.F11 (VSS_23), U2.F12 (VSS_24), U2.F13 (VSS_25), U2.F14 (AVSS_3), U2.F15 (AVSS_4), U2.G2 (VSS_26), U2.G5 (VSS_27), U2.G6 (VSS_28), U2.G10 (VSS_29), U2.G11 (VSS_30), U2.G12 (VSS_31), U2.G13 (VSS_32), U2.G16 (AVSS_5), U2.G17 (AVSS_6), U2.H4 (VSS_33), U2.H5 (VSS_34), U2.H6 (VSS_35), U2.H7 (VSS_36), U2.H10 (VSS_37), U2.H15 (VSS_38), U2.J5 (VSS_39), U2.J6 (VSS_40), U2.J12 (VSS_41), U2.J14 (VSS_42), U2.J16 (VSS_43), U2.K5 (VSS_44), U2.K6 (VSS_45), U2.K8 (VSS_46), U2.K9 (VSS_47), U2.K12 (VSS_48), U2.K13 (VSS_49)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; also elsewhere on the board
VCC_1V8_PMU: C39.1, U2.H14 (VCCIO_VDD_1V8); also elsewhere on the board
VDD_ARM: C51.1, C52.1, C53.1, C54.1, U2.N12 (ARM_VDD_1), U2.P12 (ARM_VDD_2), U2.P13 (ARM_VDD_3); also elsewhere on the board
VDD_LOGIC: C46.1, C47.1, C48.1, C49.1, C50.1, U2.H9 (LOGIC_VDD_1), U2.H13 (LOGIC_VDD_2), U2.J9 (LOGIC_VDD_3), U2.J13 (LOGIC_VDD_4), U2.L10 (LOGIC_VDD_5), U2.M11 (LOGIC_VDD_6); also elsewhere on the board
VDD_NPU_VEPU: C40.1, C41.1, C42.1, C43.1, C44.1, C45.1, C55.1, C56.1, C57.1, C58.1, C59.1, C60.1, U2.H11 (NPU_VDD_1), U2.H12 (NPU_VDD_2), U2.J10 (NPU_VDD_3), U2.J11 (NPU_VDD_4), U2.K10 (NPU_VDD_5), U2.K11 (NPU_VDD_6), U2.L9 (VEPU_VDD_1), U2.M9 (VEPU_VDD_2), U2.N8 (VEPU_VDD_3), U2.N9 (VEPU_VDD_4); also elsewhere on the board

Notes on the sheet:
NOTE: If any power domain of VCCIO 1~7 is used, then VCCIO_VDD_1V8 must be connected to 1.8V power supply

Schematic: DDR4_Sheet.kicad_sch, Leaf RV1126

Parts:
C127: 1nF X5R 25V; C_0201_0603Metric; LCSC C161477; not fitted
C128: 4.7uF X5R 10V; C_0402_1005Metric; LCSC C77004
C129, C130, C131, C133, C134, C135, C136, C137, C139, C141, C142, C143, C144, C145, C146, C169: 100nF X5R 10V; C_0402_1005Metric; LCSC C76934
C132, C167: 22uF X5R 6.3V; C_0603_1608Metric; LCSC C162690
C138: 1nF X5R 50V; C_0402_1005Metric; LCSC C77018
R66: 240R 1%; R_0402_1005Metric
R67, R68: 1K 1%; R_0402_1005Metric
U7: Samsung K4A4G165WE-BCRC; Micron_FBGA-96_9x14mm_Layout9x16_P0.8mm; LCSC C2803250

Connections:
/DDR/DDR4_D0: U7.J3 (DQ6); also elsewhere on the board
/DDR/DDR4_D1: U7.G2 (DQ0); also elsewhere on the board
/DDR/DDR4_D2: U7.H7 (DQ3); also elsewhere on the board
/DDR/DDR4_D3: U7.H8 (DQ5); also elsewhere on the board
/DDR/DDR4_D4: U7.H2 (DQ4); also elsewhere on the board
/DDR/DDR4_D5: U7.H3 (DQ2); also elsewhere on the board
/DDR/DDR4_D6: U7.J7 (DQ7); also elsewhere on the board
/DDR/DDR4_D7: U7.F7 (DQ1); also elsewhere on the board
/DDR/DDR4_D16: U7.C3 (DQ10); also elsewhere on the board
/DDR/DDR4_D17: U7.A3 (DQ8); also elsewhere on the board
/DDR/DDR4_D18: U7.D3 (DQ14); also elsewhere on the board
/DDR/DDR4_D19: U7.C2 (DQ12); also elsewhere on the board
/DDR/DDR4_D20: U7.C8 (DQ13); also elsewhere on the board
/DDR/DDR4_D21: U7.D7 (DQ15); also elsewhere on the board
/DDR/DDR4_D22: U7.C7 (DQ11); also elsewhere on the board
/DDR/DDR4_D23: U7.B8 (DQ9); also elsewhere on the board
/DDR/DDR4_DM0: U7.E7 (NF/~LDM/~LDBI); also elsewhere on the board
/DDR/DDR4_DM2: U7.E2 (NF/~UDM/~UDBI); also elsewhere on the board
/DDR/DDR4_DQS0N: U7.F3 (LDQS#); also elsewhere on the board
/DDR/DDR4_DQS0P: U7.G3 (LDQS); also elsewhere on the board
/DDR/DDR4_DQS2N: U7.A7 (UDQS#); also elsewhere on the board
/DDR/DDR4_DQS2P: U7.B7 (UDQS); also elsewhere on the board
/DDR/DDR Chips/DDR4_A0_B: U7.P3 (A0); also elsewhere on the board
/DDR/DDR Chips/DDR4_A1_B: U7.P7 (A1); also elsewhere on the board
/DDR/DDR Chips/DDR4_A2_B: U7.R3 (A2); also elsewhere on the board
/DDR/DDR Chips/DDR4_A3_B: U7.N7 (A3); also elsewhere on the board
/DDR/DDR Chips/DDR4_A4_B: U7.N3 (A4); also elsewhere on the board
/DDR/DDR Chips/DDR4_A5_B: U7.P8 (A5); also elsewhere on the board
/DDR/DDR Chips/DDR4_A6_B: U7.P2 (A6); also elsewhere on the board
/DDR/DDR Chips/DDR4_A7_B: U7.R8 (A7); also elsewhere on the board
/DDR/DDR Chips/DDR4_A8_B: U7.R2 (A8); also elsewhere on the board
/DDR/DDR Chips/DDR4_A9_B: U7.R7 (A9); also elsewhere on the board
/DDR/DDR Chips/DDR4_A10_B: U7.M3 (A10/AP); also elsewhere on the board
/DDR/DDR Chips/DDR4_A11_B: U7.T2 (A11); also elsewhere on the board
/DDR/DDR Chips/DDR4_A12_B: U7.M7 (A12/~BC); also elsewhere on the board
/DDR/DDR Chips/DDR4_A13_B: U7.T8 (A13); also elsewhere on the board
/DDR/DDR Chips/DDR4_A14_~WE_B: U7.L2 (A14/~WE); also elsewhere on the board
/DDR/DDR Chips/DDR4_A15_~CAS_B: U7.M8 (A15/~CAS); also elsewhere on the board
/DDR/DDR Chips/DDR4_A16_~RAS_B: U7.L8 (A16/~RAS); also elsewhere on the board
/DDR/DDR Chips/DDR4_BA0_B: U7.N2 (BA0); also elsewhere on the board
/DDR/DDR Chips/DDR4_BA1_B: U7.N8 (BA1); also elsewhere on the board
/DDR/DDR Chips/DDR4_BG0_B: U7.M2 (BG0); also elsewhere on the board
/DDR/DDR Chips/DDR4_CKE_B: U7.K2 (CKE); also elsewhere on the board
/DDR/DDR Chips/DDR4_CLK_B_N: U7.K8 (CK#); also elsewhere on the board
/DDR/DDR Chips/DDR4_CLK_B_P: U7.K7 (CK); also elsewhere on the board
/DDR/DDR Chips/DDR4_ODT0_B: U7.K3 (ODT); also elsewhere on the board
/DDR/DDR Chips/DDR4_~ACT_B: U7.L3 (~ACT); also elsewhere on the board
/DDR/DDR Chips/DDR4_~CS0_B: U7.L7 (~CS); also elsewhere on the board
/DDR/DDR_VREFCA: U7.M1 (V_{REFCA}); also elsewhere on the board
/DDR/DDR_~RESET: C127.1, U7.P1 (~RESET); also elsewhere on the board
/DDR/VCC2V5_DDR: C128.1, C129.2, C130.2, C131.2, U7.B1 (V_{PP}), U7.R9 (V_{PP}); also elsewhere on the board
GND: C127.2, C128.2, C129.1, C130.1, C131.1, C132.1, C133.1, C134.1, C135.1, C136.1, C137.1, C138.1, C139.1, C141.1, C142.1, C143.1, C144.1, C145.1, C146.1, C167.1, C169.1, R66.2, R67.2, R68.2, U7.A2 (V_{SSQ}), U7.A8 (V_{SSQ}), U7.B2 (V_{SS}), U7.C9 (V_{SSQ}), U7.D2 (V_{SSQ}), U7.D8 (V_{SSQ}), U7.E1 (V_{SS}), U7.E3 (V_{SSQ}), U7.E8 (V_{SSQ}), U7.E9 (V_{SS}), U7.F1 (V_{SSQ}), U7.G8 (V_{SS}), U7.H1 (V_{SSQ}), U7.H9 (V_{SSQ}), U7.K1 (V_{SS}), U7.K9 (V_{SS}), U7.M9 (V_{SS}), U7.N1 (V_{SS}), U7.T1 (V_{SS}); also elsewhere on the board
unnamed: R68.1, U7.T3 (PAR)
unnamed: R67.1, U7.N9 (TEN)
unnamed: R66.1, U7.F9 (ZQ)
VCC_DDR: C132.2, C133.2, C134.2, C135.2, C136.2, C137.2, C138.2, C139.2, C141.2, C142.2, C143.2, C144.2, C145.2, C146.2, C167.2, C169.2, U7.A1 (V_{DDQ}), U7.A9 (V_{DDQ}), U7.B3 (V_{DD}), U7.B9 (V_{DD}), U7.C1 (V_{DDQ}), U7.D1 (V_{DD}), U7.D9 (V_{DDQ}), U7.F2 (V_{DDQ}), U7.F8 (V_{DDQ}), U7.G1 (V_{DDQ}), U7.G7 (V_{DD}), U7.G9 (V_{DDQ}), U7.J1 (V_{DD}), U7.J2 (V_{DDQ}), U7.J8 (V_{DDQ}), U7.J9 (V_{DD}), U7.L1 (V_{DD}), U7.L9 (V_{DD}), U7.R1 (V_{DD}), U7.T9 (V_{DD}); also elsewhere on the board

Parts of its further copies:
C147: 1nF X5R 25V; C_0201_0603Metric; LCSC C161477; not fitted
C148: 4.7uF X5R 10V; C_0402_1005Metric; LCSC C77004
C149, C150, C151, C153, C154, C155, C156, C157, C159, C161, C162, C163, C164, C165, C166, C170: 100nF X5R 10V; C_0402_1005Metric; LCSC C76934
C152, C168: 22uF X5R 6.3V; C_0603_1608Metric; LCSC C162690
C158: 1nF X5R 50V; C_0402_1005Metric; LCSC C77018
R69: 240R 1%; R_0402_1005Metric
R70, R71: 1K 1%; R_0402_1005Metric
U8: Samsung K4A4G165WE-BCRC; Micron_FBGA-96_9x14mm_Layout9x16_P0.8mm; LCSC C2803250

Connections of its further copies:
/DDR/DDR4_A0: U8.P3 (A0); also elsewhere on the board
/DDR/DDR4_A1: U8.P7 (A1); also elsewhere on the board
/DDR/DDR4_A2: U8.R3 (A2); also elsewhere on the board
/DDR/DDR4_A3: U8.N7 (A3); also elsewhere on the board
/DDR/DDR4_A4: U8.N3 (A4); also elsewhere on the board
/DDR/DDR4_A5: U8.P8 (A5); also elsewhere on the board
/DDR/DDR4_A6: U8.P2 (A6); also elsewhere on the board
/DDR/DDR4_A7: U8.R8 (A7); also elsewhere on the board
/DDR/DDR4_A8: U8.R2 (A8); also elsewhere on the board
/DDR/DDR4_A9: U8.R7 (A9); also elsewhere on the board
/DDR/DDR4_A10: U8.M3 (A10/AP); also elsewhere on the board
/DDR/DDR4_A11: U8.T2 (A11); also elsewhere on the board
/DDR/DDR4_A12: U8.M7 (A12/~BC); also elsewhere on the board
/DDR/DDR4_A13: U8.T8 (A13); also elsewhere on the board
/DDR/DDR4_A14_~WE: U8.L2 (A14/~WE); also elsewhere on the board
/DDR/DDR4_A15_~CAS: U8.M8 (A15/~CAS); also elsewhere on the board
/DDR/DDR4_A16_~RAS: U8.L8 (A16/~RAS); also elsewhere on the board
/DDR/DDR4_BA0: U8.N2 (BA0); also elsewhere on the board
/DDR/DDR4_BA1: U8.N8 (BA1); also elsewhere on the board
/DDR/DDR4_BG0: U8.M2 (BG0); also elsewhere on the board
/DDR/DDR4_CKE: U8.K2 (CKE); also elsewhere on the board
/DDR/DDR4_CLK_N: U8.K8 (CK#); also elsewhere on the board
/DDR/DDR4_CLK_P: U8.K7 (CK); also elsewhere on the board
/DDR/DDR4_D8: U8.C3 (DQ10); also elsewhere on the board
/DDR/DDR4_D9: U8.D3 (DQ14); also elsewhere on the board
/DDR/DDR4_D10: U8.C8 (DQ13); also elsewhere on the board
/DDR/DDR4_D11: U8.D7 (DQ15); also elsewhere on the board
/DDR/DDR4_D12: U8.B8 (DQ9); also elsewhere on the board
/DDR/DDR4_D13: U8.C7 (DQ11); also elsewhere on the board
/DDR/DDR4_D14: U8.C2 (DQ12); also elsewhere on the board
/DDR/DDR4_D15: U8.A3 (DQ8); also elsewhere on the board
/DDR/DDR4_D24: U8.H2 (DQ4); also elsewhere on the board
/DDR/DDR4_D25: U8.G2 (DQ0); also elsewhere on the board
/DDR/DDR4_D26: U8.F7 (DQ1); also elsewhere on the board
/DDR/DDR4_D27: U8.J7 (DQ7); also elsewhere on the board
/DDR/DDR4_D28: U8.H8 (DQ5); also elsewhere on the board
/DDR/DDR4_D29: U8.H7 (DQ3); also elsewhere on the board
/DDR/DDR4_D30: U8.H3 (DQ2); also elsewhere on the board
/DDR/DDR4_D31: U8.J3 (DQ6); also elsewhere on the board
/DDR/DDR4_DM1: U8.E2 (NF/~UDM/~UDBI); also elsewhere on the board
/DDR/DDR4_DM3: U8.E7 (NF/~LDM/~LDBI); also elsewhere on the board
/DDR/DDR4_DQS1N: U8.A7 (UDQS#); also elsewhere on the board
/DDR/DDR4_DQS1P: U8.B7 (UDQS); also elsewhere on the board
/DDR/DDR4_DQS3N: U8.F3 (LDQS#); also elsewhere on the board
/DDR/DDR4_DQS3P: U8.G3 (LDQS); also elsewhere on the board
/DDR/DDR4_ODT0: U8.K3 (ODT); also elsewhere on the board
/DDR/DDR4_~ACT: U8.L3 (~ACT); also elsewhere on the board
/DDR/DDR4_~CS0: U8.L7 (~CS); also elsewhere on the board
/DDR/DDR_VREFCA: U8.M1 (V_{REFCA}); also elsewhere on the board
/DDR/DDR_~RESET: C147.1, U8.P1 (~RESET); also elsewhere on the board
/DDR/VCC2V5_DDR: C148.1, C149.2, C150.2, C151.2, U8.B1 (V_{PP}), U8.R9 (V_{PP}); also elsewhere on the board
GND: C147.2, C148.2, C149.1, C150.1, C151.1, C152.1, C153.1, C154.1, C155.1, C156.1, C157.1, C158.1, C159.1, C161.1, C162.1, C163.1, C164.1, C165.1, C166.1, C168.1, C170.1, R69.2, R70.2, R71.2, U8.A2 (V_{SSQ}), U8.A8 (V_{SSQ}), U8.B2 (V_{SS}), U8.C9 (V_{SSQ}), U8.D2 (V_{SSQ}), U8.D8 (V_{SSQ}), U8.E1 (V_{SS}), U8.E3 (V_{SSQ}), U8.E8 (V_{SSQ}), U8.E9 (V_{SS}), U8.F1 (V_{SSQ}), U8.G8 (V_{SS}), U8.H1 (V_{SSQ}), U8.H9 (V_{SSQ}), U8.K1 (V_{SS}), U8.K9 (V_{SS}), U8.M9 (V_{SS}), U8.N1 (V_{SS}), U8.T1 (V_{SS}); also elsewhere on the board
unnamed: R71.1, U8.T3 (PAR)
unnamed: R70.1, U8.N9 (TEN)
unnamed: R69.1, U8.F9 (ZQ)
VCC_DDR: C152.2, C153.2, C154.2, C155.2, C156.2, C157.2, C158.2, C159.2, C161.2, C162.2, C163.2, C164.2, C165.2, C166.2, C168.2, C170.2, U8.A1 (V_{DDQ}), U8.A9 (V_{DDQ}), U8.B3 (V_{DD}), U8.B9 (V_{DD}), U8.C1 (V_{DDQ}), U8.D1 (V_{DD}), U8.D9 (V_{DDQ}), U8.F2 (V_{DDQ}), U8.F8 (V_{DDQ}), U8.G1 (V_{DDQ}), U8.G7 (V_{DD}), U8.G9 (V_{DDQ}), U8.J1 (V_{DD}), U8.J2 (V_{DDQ}), U8.J8 (V_{DDQ}), U8.J9 (V_{DD}), U8.L1 (V_{DD}), U8.L9 (V_{DD}), U8.R1 (V_{DD}), U8.T9 (V_{DD}); also elsewhere on the board

Notes on the sheet:
DDR4 V_{pp} is 2.5V A stable valid V PP level is a set DC level (0 Hz to 250 KHz) and must be no less than V PP,min and no greater than V PP,max .

Schematic: PMIC_dcdc.kicad_sch, Leaf RV1126

Parts:
C68, C69, C74: 10uF X5R 10V; C_0402_1005Metric; LCSC C77000
C70: 22uF X5R 10V; C_0603_1608Metric; LCSC C162690
C71, C72, C75, C76, C78: 22uF X5R 10V; R_0603_1608Metric; LCSC C162690
C73, C77, C79: 10uF X5R 6.3V; R_0402_1005Metric; LCSC C77000
L2, L3, L4, L5: 470nH 4.53A 0.035ohm; L_1008_2520Metric; LCSC C88530
NT2, NT3, NT4: NetTie_2; NetTie-2_SMD_Pad0.5mm
R44, R45: 100R 5%; R_0402_1005Metric; LCSC C25138
R46: 110K 1%; R_0402_1005Metric
R47: 120K 1%; R_0402_1005Metric
U5: RK809-2; QFN-68-1EP_8x8mm_P0.4mm_EP6.4x6.4mm_ThermalVias

Connections:
/Power/PMIC/RK809 DCDC/VCC3V3_SYS_FB: NT2.1, U5.64 (FB4)
/Power/PMIC/RK809 DCDC/VDD_ARM_FB: NT4.2, R45.2, U5.8 (FB2)
/Power/PMIC/RK809 DCDC/VDD_NPU_VEPU_FB: NT3.2, R44.2, U5.13 (FB1)
GND: C68.1, C69.1, C70.1, C71.2, C72.2, C73.2, C74.1, C75.2, C76.2, C77.2, C78.2, C79.2, R47.2; also elsewhere on the board
unnamed: R46.2, R47.1, U5.27 (FB3)
unnamed: L2.2, U5.12 (SW1)
unnamed: L5.2, U5.9 (SW2)
unnamed: L4.2, U5.25 (SW3)
unnamed: L3.2, U5.65 (SW4)
VCC3V3_SYS: C70.2, L3.1, NT2.2; also elsewhere on the board
VCC5V0_SYS: C68.2, C69.2, C74.2, U5.10 (VCC2), U5.11 (VCC1), U5.24 (VCC3), U5.66 (VCC4); also elsewhere on the board
VCC_DDR: C78.1, C79.1, L4.1, R46.1, U5.26 (VBUCK3); also elsewhere on the board
VDD_ARM: C75.1, C76.1, C77.1, L5.1, NT4.1, R45.1; also elsewhere on the board
VDD_NPU_VEPU: C71.1, C72.1, C73.1, L2.1, NT3.1, R44.1; also elsewhere on the board

Notes on the sheet:
DDR Type | VCC_DDR Voltage | R46 DDR4 | 1.21V | 62K LPDDR3 | 1.21V | 62K DDR3L | 1.35V | 82K DDR3 | 1.53V | 100K LPDDR4 | 1.14V | 51K
Feedback from far-end

Schematic: PMIC_LDO.kicad_sch, Leaf RV1126

Parts:
C80, C82, C83, C86, C87, C88, C90, C91, C92, C94: 1uF X5R 10V; C_0402_1005Metric; LCSC C77007
C81, C85, C89, C93: 1uF X5R 6.3V; C_0402_1005Metric; LCSC C15684
C84: 4.7uF X5R 10V; C_0402_1005Metric; LCSC C77004
C95, C96: 22uF X5R 10V; R_0603_1608Metric; LCSC C162690
C97: 10uF X5R 10V; C_0402_1005Metric; LCSC C77000
L6: 470nH 4.53A 0.035ohm; L_1008_2520Metric; LCSC C88530
U5: RK809-2; QFN-68-1EP_8x8mm_P0.4mm_EP6.4x6.4mm_ThermalVias

Connections:
GND: C80.2, C81.2, C82.2, C83.2, C84.2, C85.2, C86.2, C87.2, C88.2, C89.2, C90.2, C91.2, C92.2, C93.2, C94.2, C95.2, C96.2, C97.2; also elsewhere on the board
unnamed: L6.2, U5.53 (SW5)
VCC1V8_DOVDD: C86.1, U5.29 (LDO5)
VCC3V3_SYS: C93.1, U5.57 (VCC8); also elsewhere on the board
VCC5V0_SYS: C89.1, C97.1, U5.4 (VCC7), U5.54 (VCC9); also elsewhere on the board
VCCAVDD_RGB: C88.1, U5.3 (LDO7)
VCCDVDD_RGB: C87.1, U5.31 (LDO6)
VCCIO_SD: C90.1, U5.5 (LDO8); also elsewhere on the board
VCC_0V8: C80.1, U5.23 (LDO1); also elsewhere on the board
VCC_0V8_PMU: C83.1, U5.20 (LDO3); also elsewhere on the board
VCC_1V8: C84.1, U5.28 (LDO4); also elsewhere on the board
VCC_1V8_PMU: C82.1, U5.21 (LDO2); also elsewhere on the board
VCC_3V3: C92.1, U5.58 (SWOUT2); also elsewhere on the board
VCC_3V3_SD: C91.1, U5.6 (LDO9); also elsewhere on the board
VCC_5V0: C94.1, U5.55 (SWOUT1)
VCC_BUCK5: C81.1, C85.1, C95.1, C96.1, L6.1, U5.22 (VCC5), U5.30 (VCC6), U5.59 (FB5); also elsewhere on the board

Schematic: PMIC_management.kicad_sch, Leaf RV1126

Parts:
BT1: Battery_Cell; TestPoint_2Pads_Pitch5.08mm_Drill1.3mm
C61, C62: 1uF X5R 6.3V; C_0402_1005Metric; LCSC C15684
C63, C64: 22pF 50V C0G; C_0201_0603Metric; LCSC C76924
C65: 10nF 25V X5R; C_0402_1005Metric; LCSC C327025
C66: 100nF X5R 6.3V; C_0402_1005Metric; LCSC C161163
C67: 100nF X5R 6.3V; C_0201_0603Metric; LCSC C76928
D13, D14: ESD 5.0V; D_SOD-923; LCSC C172403
D15: ESD 3.3V; D_SOD-923; LCSC C172400
R35, R36: R; not fitted
R37: R_Shunt; not fitted
R38, R39: 2.2kΩ ±5%; R_0201_0603Metric; LCSC C142018
R40: 450K 1%; R_0402_1005Metric
R41: 22R 5%; R_0402_1005Metric; LCSC C59651
R42: 47K 1%; R_0402_1005Metric
R43: 4.7K 5%; R_0201_0603Metric; LCSC C270346
SW1, SW2: SKSGPAE010; SW_SPST_ALPS_SKSG_3.9x2.7mm; LCSC C125045
TP3: TestPoint; TestPoint_Pad_D1.0mm
U5: RK809-2; QFN-68-1EP_8x8mm_P0.4mm_EP6.4x6.4mm_ThermalVias
Y2: 32.768kHz ±20ppm 12.5pF; Crystal_SMD_3215-2Pin_3.2x1.5mm; LCSC C32346

Connections:
/PMIC_CLK32K: R41.1; also elsewhere on the board
/PMIC_I2C_SCL: R39.2, U5.2 (SDA); also elsewhere on the board
/PMIC_I2C_SDA: R38.2, U5.1 (SCL); also elsewhere on the board
/PMIC_INT: U5.7 (INT); also elsewhere on the board
/PMIC_RESET: C66.1, D15.2 (A2), R43.2, SW2.1, U5.67 (RESETB); also elsewhere on the board
/PMIC_SLEEP: U5.49 (SLEEP); also elsewhere on the board
/Power/PMIC/RK809 Management/BATDIV: R35.2, R36.1, U5.56 (BATDIV)
/Power/PMIC/RK809 Management/PWR_ON: C67.1, D14.2 (A2), SW1.1, U5.52 (PWRON)
/Power/PMIC/RK809 Management/SNSN: R37.3, U5.63 (SNSN)
/Power/PMIC/RK809 Management/SNSP: R37.2, U5.62 (SNSP)
GND: C61.1, C62.2, C63.1, C64.1, C65.2, C66.2, C67.2, D13.1 (A1), D14.1 (A1), D15.1 (A1), R37.4, R42.2, SW1.2, SW1.3 (GND), SW2.2, SW2.3 (GND), U5.47 (GNDREF), U5.69 (ePAD); also elsewhere on the board
unnamed: BT1.2 (-), R36.2, R37.1
unnamed: R41.2, U5.68 (CLK32K)
unnamed: TP3.1, U5.60 (EXT_EN)
unnamed: C65.1, R40.2, R42.1, U5.61 (VDC)
unnamed: C61.2, U5.46 (VREF)
unnamed: C63.2, U5.50 (XIN), Y2.1
unnamed: C64.2, U5.51 (XOUT), Y2.2
VCC3V3: R38.1, R39.1, R43.1
VCC5V0_SYS: BT1.1 (+), C62.1, D13.2 (A2), R35.1, R40.1, U5.45 (VCC_RTC); also elsewhere on the board

Notes on the sheet:
PWR_ON: Power on key input, active low, internal 17k resistor pull high to VCC_RTC
还需要考虑充电/保护电路
需要与 RK809 的 DataSheet中的参 考电路(双电池)的 设计对比

Schematic: PMIC_codec.kicad_sch, Leaf RV1126

Parts:
C98: 10uF X5R 10V; C_0402_1005Metric; LCSC C77000
C99, C101: 2.2uF X5R 10V; C_0402_1005Metric
C100, C102, C103: 1uF X5R 6.3V; C_0402_1005Metric; LCSC C15684
C104, C106: 100nF X5R 6.3V; C_0201_0603Metric; LCSC C76928
C105, C107: 27pF C0G 50V; C_0201_0603Metric; LCSC C384976
R48, R49, R50, R51, R52, R53: 22R 5%; R_0402_1005Metric; LCSC C59651
R54: 0R 5%; R_0402_1005Metric; LCSC C17168
U5: RK809-2; QFN-68-1EP_8x8mm_P0.4mm_EP6.4x6.4mm_ThermalVias

Connections:
/Power/PMIC/RK809 Codec/HPL_OUT: U5.39 (HPL_OUT)
/Power/PMIC/RK809 Codec/HPR_OUT: U5.41 (HPR_OUT)
/Power/PMIC/RK809 Codec/HP_SNS: U5.40 (HP_SNS)
/Power/PMIC/RK809 Codec/I2S_LRCLK_TX: R50.2, U5.14 (LRCLK)
/Power/PMIC/RK809 Codec/I2S_LRCLK_TX_M0: R50.1
/Power/PMIC/RK809 Codec/I2S_MCLK: R48.2, U5.16 (MCLK)
/Power/PMIC/RK809 Codec/I2S_MCLK_M0: R48.1
/Power/PMIC/RK809 Codec/I2S_SCLK_TX: R49.2, U5.15 (BCLK)
/Power/PMIC/RK809 Codec/I2S_SCLK_TX_M0: R49.1
/Power/PMIC/RK809 Codec/I2S_SDI0: R52.2, U5.18 (SDO/PDMDATA)
/Power/PMIC/RK809 Codec/I2S_SDI0_M0: R52.1
/Power/PMIC/RK809 Codec/I2S_SDO0: R51.2, U5.17 (SDI)
/Power/PMIC/RK809 Codec/I2S_SDO0_M0: R51.1
/Power/PMIC/RK809 Codec/PDM_CLK1: R53.1
/Power/PMIC/RK809 Codec/RK809_MIC_INN: C106.1
/Power/PMIC/RK809 Codec/RK809_MIC_INP: C104.1
/Power/PMIC/RK809 Codec/SPKN_OUT: U5.34 (SPKN_OUT)
/Power/PMIC/RK809 Codec/SPKP_OUT: U5.32 (SPKP_OUT)
GND: C98.2, C100.2, C101.2, C102.2, C103.2, C105.2, C107.2, R54.1; also elsewhere on the board
unnamed: C99.1, U5.36 (CPN)
unnamed: C99.2, U5.37 (CPP)
unnamed: C106.2, C107.1, U5.42 (MICIN)
unnamed: C104.2, C105.1, U5.43 (MICIP)
unnamed: R53.2, R54.2, U5.19 (PDMCLK)
unnamed: C103.1, U5.44 (VCC_1P8A)
unnamed: C102.1, U5.48 (VCC_1P8D)
unnamed: C100.1, U5.38 (VCC_CPVDD)
unnamed: C101.1, U5.35 (VCC_CPVSS)
VCC5V0_SYS: C98.1, U5.33 (VCC_SKP_HP); also elsewhere on the board

Notes on the sheet:
If there is loopback function:R15 = 0R R16 = DNP. If there is no loopback function:R15 = DNP, R16 = 0R.

Board: 6 copper layers, 49.8 x 49.7 mm, 290 parts (88 on the bottom side), 236 nets.

Notices in the files:
DDR4_Sheet.kicad_sch:
License: CC BY-SA
